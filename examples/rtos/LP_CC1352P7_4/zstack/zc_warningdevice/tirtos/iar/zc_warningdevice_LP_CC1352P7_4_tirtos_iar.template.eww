<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/zc_warningdevice_LP_CC1352P7_4_tirtos_iar.ewp</path>
  </project>
  <batchBuild/>
</workspace>
