<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/dmm_zc_switch_remote_display_app_CC1352P_2_LAUNCHXL_tirtos_iar.ewp</path>
  </project>
  <batchBuild/>
</workspace>
