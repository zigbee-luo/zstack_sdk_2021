<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/dmm_zr_light_remote_display_oad_app_CC1352R1_LAUNCHXL_tirtos_iar.ewp</path>
  </project>
  <batchBuild/>
</workspace>
