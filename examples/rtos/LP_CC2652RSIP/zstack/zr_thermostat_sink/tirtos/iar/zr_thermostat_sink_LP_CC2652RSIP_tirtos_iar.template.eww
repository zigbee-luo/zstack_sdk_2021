<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/zr_thermostat_sink_LP_CC2652RSIP_tirtos_iar.ewp</path>
  </project>
  <batchBuild/>
</workspace>
