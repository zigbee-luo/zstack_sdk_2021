<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/zed_genericapp_CC1352P_4_LAUNCHXL_tirtos_iar.ewp</path>
  </project>
  <batchBuild/>
</workspace>
