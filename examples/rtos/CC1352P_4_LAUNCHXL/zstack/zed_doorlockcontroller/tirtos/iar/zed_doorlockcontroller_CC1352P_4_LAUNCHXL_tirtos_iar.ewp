# IAR project zed_doorlockcontroller_CC1352P_4_LAUNCHXL_tirtos_iar.ewp, settings and files
configuration default (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  group (top)
    ./: zed_doorlockcontroller_CC1352P_4_LAUNCHXL_tirtos_iar.ipcf SysConfig_Generated_Files.ipcf app.cfg
